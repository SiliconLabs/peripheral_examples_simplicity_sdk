# IAR project EFR32MG27_eusart_async_half_duplex.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG27C140F768IM40 SiliconLaboratories EFR32MG27C140F768IM40
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG27C140F768IM40; SL_LEGACY_LINKER
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG27\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32MG27_BRD4194A; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG27C140F768IM40; SL_LEGACY_LINKER
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG27_eusart_async_half_duplex.bin
  ILINK.IlinkOutputFile: EFR32MG27_eusart_async_half_duplex.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG27C140F768IM40; SL_LEGACY_LINKER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG27C140F768IM40; SL_LEGACY_LINKER
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG27/Source/: startup_efr32mg27.c system_efr32mg27.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_eusart.c em_system.c em_usart.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../src/: main_xg27.c
    ../: readme.txt
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi.c
