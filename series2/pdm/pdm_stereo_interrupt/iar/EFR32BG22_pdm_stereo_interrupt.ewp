# IAR project EFR32BG22_pdm_stereo_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG22C224F512IM40 SiliconLaboratories EFR32BG22C224F512IM40
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32BG22C224F512IM40; SL_LEGACY_LINKER
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG22\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32BG22_BRD4184A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG22C224F512IM40; SL_LEGACY_LINKER
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG22_pdm_stereo_interrupt.bin
  ILINK.IlinkOutputFile: EFR32BG22_pdm_stereo_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG22C224F512IM40; SL_LEGACY_LINKER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32BG22C224F512IM40; SL_LEGACY_LINKER
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG22/Source/: startup_efr32bg22.c system_efr32bg22.c
  group emlib
    ../../../../../platform/emlib/src/: em_core.c em_cmu.c em_emu.c em_gpio.c em_pdm.c em_system.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../src/: main_xg22_pdm_stereo_interrupt.c
    ../: readme.txt
