# IAR project EFR32MG22_iadc_single_letimer_prs_ldma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG22C224F512IM40 SiliconLaboratories EFR32MG22C224F512IM40
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG22C224F512IM40
  ICCARM.CCDiagSuppress: Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG22\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG22_BRD4182A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG22C224F512IM40
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG22_iadc_single_letimer_prs_ldma.bin
  ILINK.IlinkOutputFile: EFR32MG22_iadc_single_letimer_prs_ldma.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG22C224F512IM40
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG22C224F512IM40
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG22/Source/IAR/: startup_efr32mg22.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG22/Source/: system_efr32mg22.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_iadc.c em_ldma.c em_letimer.c em_prs.c em_system.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../src/: main_single_letimer_prs_ldma_xg21_xg22.c
    ../: readme.txt
