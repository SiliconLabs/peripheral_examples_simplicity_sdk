# IAR project EFR32MG24_i2c_follower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24B210F1536IM48 SiliconLaboratories EFR32MG24B210F1536IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG24B210F1536IM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32MG24_BRD4186C; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers; ..\..\..\..\..\platform\peripheral\inc; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG24B210F1536IM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG24_i2c_follower.bin
  ILINK.IlinkOutputFile: EFR32MG24_i2c_follower.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG24B210F1536IM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG24B210F1536IM48
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/IAR/: startup_efr32mg24.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/: system_efr32mg24.c
  group emlib
    ../../../../../platform/emlib/src/: em_i2c.c em_cmu.c em_core.c em_emu.c em_gpio.c em_usart.c em_system.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group peripheral
    ../../../../../platform/peripheral/src/: sl_hal_sysrtc.c
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi.c
  group Source
    ../: readme.txt
    ../src/: main.c
