# IAR project EFR32FG25_i2c_follower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG25B222F1920IM56 SiliconLaboratories EFR32FG25B222F1920IM56
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32FG25B222F1920IM56
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32FG25\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\peripheral\inc; ..\..\..\kit\EFR32FG25_BRD4270B; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32FG25B222F1920IM56
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32FG25_i2c_follower.bin
  ILINK.IlinkOutputFile: EFR32FG25_i2c_follower.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32FG25B222F1920IM56
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32FG25B222F1920IM56
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32FG25/Source/IAR/: startup_efr32fg25.s
    ../../../../../platform/Device/SiliconLabs/EFR32FG25/Source/: system_efr32fg25.c
  group emlib
    ../../../../../platform/emlib/src/: em_i2c.c em_cmu.c em_core.c em_emu.c em_eusart.c em_gpio.c em_system.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group peripheral
    ../../../../../platform/peripheral/src/: sl_hal_sysrtc.c
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi_eusart.c
  group Source
    ../: readme.txt
    ../src/: main.c
