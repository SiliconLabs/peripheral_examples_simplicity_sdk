# IAR project EFR32MG24_pcnt_single_oversampling_underflow.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24B210F1536IM48 SiliconLaboratories EFR32MG24B210F1536IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG24B210F1536IM48
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32MG24_BRD4186C; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG24B210F1536IM48
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG24_pcnt_single_oversampling_underflow.bin
  ILINK.IlinkOutputFile: EFR32MG24_pcnt_single_oversampling_underflow.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG24B210F1536IM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG24B210F1536IM48
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/IAR/: startup_efr32mg24.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/: system_efr32mg24.c
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi.c
  group emlib
    ../../../../../platform/emlib/src/: em_system.c em_core.c em_cmu.c em_pcnt.c em_gpio.c em_prs.c em_emu.c em_usart.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../src/: main.c
    ../: readme.txt
