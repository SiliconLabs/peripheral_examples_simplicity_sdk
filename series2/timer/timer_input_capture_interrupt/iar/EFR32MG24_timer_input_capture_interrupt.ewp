# IAR project EFR32MG24_timer_input_capture_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24B210F1536IM48 SiliconLaboratories EFR32MG24B210F1536IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG24B210F1536IM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32MG24_BRD4186C; ..\..\..\kit\common\bsp; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG24B210F1536IM48; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG24_timer_input_capture_interrupt.bin
  ILINK.IlinkOutputFile: EFR32MG24_timer_input_capture_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG24B210F1536IM48; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG24B210F1536IM48; RETARGET_VCOM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/IAR/: startup_efr32mg24.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG24/Source/: system_efr32mg24.c
  group emlib
    ../../../../../platform/emlib/src/: em_core.c em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../src/: main.c
    ../: readme.txt
