# IAR project EFR32MG21_usart_spi_secondary_dma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG21A010F1024IM32
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFR32MG21_BRD4181A\config; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG21A010F1024IM32
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32MG21_usart_spi_secondary_dma.bin
  ILINK.IlinkOutputFile: EFR32MG21_usart_spi_secondary_dma.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG21A010F1024IM32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG21A010F1024IM32
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/IAR/: startup_efr32mg21.s
    ../../../../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_system.c em_usart.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Source
    ../: readme.txt
    ../src/: main_xg21.c
