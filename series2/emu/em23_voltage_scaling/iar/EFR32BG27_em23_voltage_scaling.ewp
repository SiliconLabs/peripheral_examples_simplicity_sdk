# IAR project EFR32BG27_em23_voltage_scaling.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG27C320F768GJ39 SiliconLaboratories EFR32BG27C320F768GJ39
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32BG27C320F768GJ39
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Core\Include; ..\..\..\..\..\platform\common\inc; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG27\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\kit\EFR32BG27_BRD4111A; ..\..\..\kit\common\bsp; ..\..\..\kit\common\drivers; ..\..\..\..\..\platform\common\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32BG27C320F768GJ39
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EFR32BG27_em23_voltage_scaling.bin
  ILINK.IlinkOutputFile: EFR32BG27_em23_voltage_scaling.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32BG27C320F768GJ39
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32BG27C320F768GJ39
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFR32BG27/Source/IAR/: startup_efr32bg27.s
    ../../../../../platform/Device/SiliconLabs/EFR32BG27/Source/: system_efr32bg27.c
  group emlib
    ../../../../../platform/emlib/src/: em_burtc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_system.c em_usart.c
  group platform
    ../../../../../platform/common/src/: sl_core_cortexm.c sl_syscalls.c
  group Drivers
    ../../../kit/common/drivers/: mx25flash_spi.c
  group Source
    ../: readme.txt
    ../src/: main_xg27_boost.c
